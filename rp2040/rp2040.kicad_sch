File: rp2040/rp2040.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: rp2040: update to kicad 9.0.2
Other:
- company: (none) -> Tom Keddie
